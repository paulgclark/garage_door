options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: fosphor_scan
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      After running the flowgraph,
      you'll move the slider until
      you find the signal present
      in the scanner when the
      button is pressed.
    orient: Qt.Horizontal
    start: 120e6
    step: samp_rate
    stop: 1000e6
    value: 120e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_freq
    freq_span: samp_rate
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
