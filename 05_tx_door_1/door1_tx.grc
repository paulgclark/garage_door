options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bits_0_5
  id: variable
  parameters:
    value: seq_zero + seq_zero + seq_one + seq_one + seq_zero + seq_one
  states: {}
- name: bits_7_8
  id: variable
  parameters:
    value: seq_one + seq_zero
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 390.5e6
  states: {}
- name: dead_air
  id: variable
  parameters:
    value: 40*(0,)
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 390e6
  states: {}
- name: payload
  id: variable
  parameters:
    value: 'seq_x + bits_0_5 + seq_x + bits_7_8 + seq_x '
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '5'
    stop: '75'
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: seq_one
  id: variable
  parameters:
    comment: |-
      Set to sequence
      representing a
      logical 1
    value: (0, )
  states: {}
- name: seq_x
  id: variable
  parameters:
    comment: |-
      Set to sequence
      representing the
      special bit
    value: (0, )
  states: {}
- name: seq_zero
  id: variable
  parameters:
    comment: |-
      Set to sequence
      representing a
      logical 0
    value: (0,)
  states: {}
- name: symbol_time
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq-center_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate*symbol_time)
    type: float
  states: {}
- name: blocks_vector_source_x_0_0_0_1_0
  id: blocks_vector_source_x
  parameters:
    comment: |-
      Set this such that the
      flowgraph transmits
      a burst of 10 transmissions
      using the payload
      variable and one other
    repeat: 'False'
    type: float
    vector: payload
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_repeat_0, '0', blocks_float_to_complex_0, '0']
- [blocks_vector_source_x_0_0_0_1_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
