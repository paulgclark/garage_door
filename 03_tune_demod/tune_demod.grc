options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: garage_remote_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 390e6
  states: {}
- name: chan_width
  id: variable_qtgui_range
  parameters:
    comment: |-
      This must be set to the
      a value that is **larger**
      than the observed width 
      of the signal peak in the
      frequency plot. Too small
      and the signal will be 
      distorted. Too large and
      the noise level will
      be higher.
    orient: Qt.Horizontal
    start: 3e3
    step: 1e3
    stop: 100e3
    value: 3e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      You'll need to 
      modify this to
      match the observed
      frequency from
      step 1
    orient: Qt.Horizontal
    start: 388e6
    step: 50e3
    stop: 392e6
    value: 389e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    comment: |-
      This must be set to
      a midpoint between 
      the high (logic 1) and 
      low (logic 0) levels of 
      the raw demodulated 
      waveform.
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.5'
    value: '0'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1 * threshold'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/paul/garage_door/remote_00_c390M_s1M.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq - center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, chan_width, chan_width/10)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"After Tuning"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '1024'
    name: '"Raw Capture RF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: 1024*16
    srate: working_samp_rate
    type: float
    yunit: '"Demodulated OOK"'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
