options:
  parameters:
    author: paul
    generate_options: qt_gui
    id: garage_remote_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 390e6
  states: {}
- name: chan_width
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 3e3
    step: 1e3
    stop: 100e3
    value: 30e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 388e6
    step: 50e3
    stop: 392e6
    value: 390e6
  states: {}
- name: preamble_str
  id: variable
  parameters:
    comment: |-
      Set this to a string of
      0s and 1s that uniquely
      denote the start of a 
      transmission
    value: '"01010101"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: working_samp_rate * symbol_len
  states: {}
- name: symbol_len
  id: variable
  parameters:
    comment: |-
      Set this to the length
      of the minimum time
      observed in the
      demodulated 
      waveform
    value: '15e-3'
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 1/symbol_len
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '0.2'
    value: '0.025'
  states: {}
- name: working_samp_rate
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1 * threshold'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-0.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/paul/garage_door/remote_00_c390M_s1M.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: int(sps)
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq - center_freq
    decim: int(samp_rate/working_samp_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, chan_width, chan_width/10)
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: working_samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"After Tuning"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"Raw Capture RF"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: 1024*2
    srate: working_samp_rate
    tr_chan: '1'
    tr_delay: '1e-3'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    yunit: '"Demodulated OOK"'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    name: '"Sync Output"'
    size: '256'
    srate: symbol_rate
    tr_delay: '1e-3'
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: reveng_message_print_0
  id: reveng_message_print
  parameters:
    display_ascii: '0'
  states: {}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '40'
    sync: preamble_str
    threshold: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_add_const_vxx_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_uchar_to_float_1, '0']
- [digital_binary_slicer_fb_1, '0', satellites_sync_to_pdu_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [satellites_sync_to_pdu_0, out, reveng_message_print_0, msg_in]

metadata:
  file_format: 1
